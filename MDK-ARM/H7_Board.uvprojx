# Keil uVision project H7_Board.uvprojx, settings and files
target H7_Board (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H7_Board +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_ROUNDING
  c misc: --cpp11
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/DSP/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Development_Layer\Driver\ADC;..\Development_Layer\Driver\FDCAN;..\Development_Layer\Driver\LED_and_BUZZER;..\Development_Layer\Driver\Math;..\Development_Layer\Driver\SPI;..\Development_Layer\Driver\TIM;..\Development_Layer\Driver\USB;..\Development_Layer\Driver\Matrix;..\Development_Layer\Driver\UART;../Development_Layer/External_Device/DR16;..\Development_Layer\External_Device\BMI088;../Development_Layer/External_Device/Motor/Motor_DJI;../Development_Layer/External_Device/Motor/Motor_DM;../Development_Layer/External_Device/PowerMeter;..\Development_Layer\External_Device\DM_IMU;../Development_Layer/External_Device/Referee;../Development_Layer/Function_Class/CLass_FSM;../Development_Layer/Function_Class/Class_Robot;../Development_Layer/Function_Class/Class_Sampling;../Development_Layer/Function_Class/Class_Slope;../Development_Layer/Function_Class/Class_Timer;../Development_Layer/Robot_Control/Booster;../Development_Layer/Robot_Control/Controller;../Development_Layer/Robot_Control/Filter;../Development_Layer/Robot_Control/Gimbal;../Development_Layer/Task/CallBack_Task;../Development_Layer/Task/RTOS_Task;../Development_Layer/User_Debug/Debug_Config;../Development_Layer/User_Debug/Serial_Debug;..\Development_Layer\Driver\DC_Source;../Development_Layer/External_Device/Fire_Manage;../Development_Layer/External_Device/PC_Driver;../Middlewares/ST/ARM/DSP/Inc;..\Development_Layer\External_Device\G_C_Communicate;..\Development_Layer\Function_Class\Class_CRC;..\Development_Layer\External_Device\VTM_RX;..\Development_Layer\External_Device\TOF050F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c ramecc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Driver
    ../Development_Layer/Driver/ADC/: drv_adc.cpp drv_adc.h
    ../Development_Layer/Driver/DC_Source/: dc_source.cpp dc_source.h
    ../Development_Layer/Driver/FDCAN/: drv_fdcan.cpp drv_fdcan.h
    ../Development_Layer/Driver/LED_and_BUZZER/: led_and_buzzer.cpp led_and_buzzer.h
    ../Development_Layer/Driver/Math/: drv_math.cpp drv_math.h
    ../Development_Layer/Driver/Matrix/: matrix.cpp matrix.h
    ../Development_Layer/Driver/SPI/: drv_spi.cpp drv_spi.h
    ../Development_Layer/Driver/TIM/: drv_tim.cpp drv_tim.h
    ../Development_Layer/Driver/UART/: drv_uart.cpp drv_uart.h
    ../Development_Layer/Driver/USB/: drv_usb.cpp drv_usb.h
  group External_Device
    ../Development_Layer/External_Device/DR16/: dr16.cpp dr16.h
    ../Development_Layer/External_Device/Motor/Motor_DJI/: motor_dji.cpp motor_dji.h
    ../Development_Layer/External_Device/Motor/Motor_DM/: motor_dm.cpp motor_dm.h
    ../Development_Layer/External_Device/PC_Driver/: pc_driver.cpp pc_driver.h pc_packet.h
    ../Development_Layer/External_Device/Referee/: referee.cpp referee.h
    ../Development_Layer/External_Device/Fire_Manage/: fire_manage.cpp fire_manage.h
    ../Development_Layer/External_Device/BMI088/: imu.h imu.cpp BMI088_Reg.h QuaternionEKF.h QuaternionEKF.c kalman_filter.h kalman_filter.c BMI088_Driver.h BMI088_Driver.c
    ../Development_Layer/External_Device/DM_IMU/: dm_imu.cpp dm_imu.h
    ../Development_Layer/External_Device/G_C_Communicate/: g_c_communicate.cpp g_c_communicate.h
    ../Development_Layer/External_Device/VTM_RX/: vtm_rx.cpp vtm_rx.h
    ../Development_Layer/External_Device/TOF050F/: tof050.cpp tof050.h
  group Funtion_Class
    ../Development_Layer/Function_Class/CLass_FSM/: fsm_class.cpp fsm_class.h
    ../Development_Layer/Function_Class/Class_Robot/: rbt_class.cpp rbt_class.h
    ../Development_Layer/Function_Class/Class_Sampling/: sampling_queue.cpp sampling_queue.h
    ../Development_Layer/Function_Class/Class_Slope/: slope_class.cpp slope_class.h
    ../Development_Layer/Function_Class/Class_Timer/: class_timer.cpp class_timer.h
    ../Development_Layer/Function_Class/Class_CRC/: protocol_crc.cpp protocol_crc.h
  group Robot_Control
    ../Development_Layer/Robot_Control/Booster/: booster.cpp booster.h
    ../Development_Layer/Robot_Control/Gimbal/: gimbal.cpp gimbal.h gimbal_motor.cpp gimbal_motor.h
    ../Development_Layer/Robot_Control/Controller/: LQR.cpp LQR.h PID.cpp PID.h
    ../Development_Layer/Robot_Control/Filter/: filter.cpp filter.h
  group Task
    ../Development_Layer/Task/CallBack_Task/: callback_task.cpp callback_task.h
    ../Development_Layer/Task/RTOS_Task/: rtos_task.cpp rtos_task.h
  group User_Debug
    ../Development_Layer/User_Debug/Debug_Config/: User_debug_config.h
    ../Development_Layer/User_Debug/Serial_Debug/: Serial_Debug.cpp Serial_Debug.h
  group DSP_Lib
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
software components: CMSIS:CORE 6.1.1
